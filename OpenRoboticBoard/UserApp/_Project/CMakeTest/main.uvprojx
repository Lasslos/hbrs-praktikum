# Keil uVision project main.uvprojx, settings and files
target Target (6160000::V6.16::ARMCLANG)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: main +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_UART,STM32F405xx, __ARM_STM32F405__, _HSE_CLK=8000, _HSE_BYPASS_OFF, HSE_VALUE=8000000,HSI_VALUE=8000000,_KEIL
  c include: {ORB}\Firmware;{ORB}\Middleware\Src;.\Src;..\..\..\Firmware;..\..\..\Middleware\Src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT5: ROM 0x8020000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x1000
  link misc: --diag_suppress=6305,6314
  group Lib
    ./Lib/: entry.cpp main.cpp startup.s
  group App
    ./Src/: Application.h
